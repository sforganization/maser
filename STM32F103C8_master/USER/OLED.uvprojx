# Keil uVision project OLED.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OLED +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\OLED;..\HARDWARE\AS608;..\HARDWARE\TIMER;..\HARDWARE\USART2;..\HARDWARE\COMMENT;..\HARDWARE\REMOTE;..\HARDWARE\FLASH;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\USART1;..\HARDWARE\USART3;..\HARDWARE\TIM_PWM
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/AS608/: as608.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/COMMENT/: SysComment.c
    ../HARDWARE/FLASH/: San_Flash.c
    ../HARDWARE/USART1/: usart1.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/TIM_PWM/: pwm.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../STM32F10x_FWLib/src/: stm32f10x_tim.c stm32f10x_exti.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_flash.c
software components: CMSIS:CORE 5.0.1
